# Keil uVision project Embedded_GPS_Tracking_System.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Embedded_GPS_Tracking_System +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s system_TM4C123.c
    ./Services/: Bit_Utilities.h tm4c123gh6pm.h
    ./src/MCAL/: UART.c EEPROM.c GPIO.c Systick.c
    ./Headers/MCAL/: UART.h EEPROM.h GPIO.h Systick.h
    ./src/APP/: main.c APP.c
    ./Headers/HAL/: GPS.h Landmarks.h LCD.h LED.h
    ./src/HAL/: GPS.c Landmarks.c LCD.c LED.c
    ./Headers/APP/: APP.h
    ./Test/: Systick_test.c Uart_test.c Eeprom_test.c GPIO_test.c LCD_test.c GPS_test.c
